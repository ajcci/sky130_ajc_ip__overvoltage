v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -50 -40 0 0 {name=p1 lab=VPWR sim_pinnumber=0}
C {devices/ipin.sym} -50 -20 0 0 {name=p2 lab=VGND sim_pinnumber=1}
C {devices/ipin.sym} -50 0 0 0 {name=p3 lab=otrip[3:0] sim_pinnumber=2}
C {devices/opin.sym} -10 -40 0 0 {name=p4 lab=otrip_decoded[15:0] sim_pinnumber=3}
