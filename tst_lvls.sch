v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {xschem/sky130_fd_sc_hvl__lsbufhv2lv_simple_1.sym} 0 0 0 0 {name=x1 LVPWR=dvdd VGND=avss VNB=avss VPB=avdd VPWR=avdd prefix=sky130_fd_sc_hvl__ }
